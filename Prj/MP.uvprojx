# Keil uVision project MP.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MP +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\App;..\Bsp;..\Fwlib\stdlib\inc;..\uCos_ii\uCSource;..\uCos_ii\uCCPU;..\uCos_ii\uCPort;..\uCos_ii;..\Fwlib;..\uCos_ii\uCLib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: app.c stm32f10x_it.c modbus.c
    ../Fwlib/: system_stm32f10x.c
  group Bsp
    ../Bsp/: bsp.c gpio.c uart.c
  group FwLib
    ../Fwlib/stdlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_usart.c
  group Startup
    ../Fwlib/startup/arm/: startup_stm32f10x_hd.s
  group uCCPU
    ../uCos_ii/uCCPU/: cpu_a.asm cpu_c.c
  group uCPort
    ../uCos_ii/uCPort/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCSource
    ../uCos_ii/uCSource/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
software components: CMSIS:CORE 5.0.0
